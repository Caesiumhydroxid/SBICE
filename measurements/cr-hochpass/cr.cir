V1 0 in AC 1
R3 in 2 11.9
C1 2 3 3.3n
R1 3 0 2.7k
