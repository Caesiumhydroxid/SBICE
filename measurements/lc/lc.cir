V1 0 in AC 1
R3 in 2 11.9
L1 2 3 50m
C1 3 0 100n
