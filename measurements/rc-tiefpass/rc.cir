V1 0 in AC 1
R3 in 2 11.9
R1 2 3 2.7k
C1 3 0 3.3n
