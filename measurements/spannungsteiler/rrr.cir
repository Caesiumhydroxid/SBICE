V1 0 in DC 2
R3 in 2 11.72
R1 2 3 1.2k
R2 3 0 1.8k
